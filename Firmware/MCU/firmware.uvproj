# Keil uVision project firmware.uvproj, settings and files
target Target 1 (166/167)
  device: 1887VE3T Generic
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xD800-0xE7FF) IROM(0x000000-0x07FFF) IROM2(0x018000-0x04FFFF) CLOCK(20000000) MOD167
  output: firmware +hex
  group ProjectFiles
    ./: START_V2.A66 main.c flash.c exin.c asc0.c can.c settings.c asm_exin.a66 algorithm.c
